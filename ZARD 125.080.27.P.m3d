# KOMPAS-3D part (ZARD 125.080.27.P.m3d)

Model tree:
1. Операция без истории:1
